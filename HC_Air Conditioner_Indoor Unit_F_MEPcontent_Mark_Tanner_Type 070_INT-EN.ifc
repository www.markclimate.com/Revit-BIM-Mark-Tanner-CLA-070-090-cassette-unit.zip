Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2024-06-04T15:03:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 04 15:03:36 2024 * Host: AGHARAT-IN-LE01 * Database: C:\Users\agharat\AppData\Local\Temp\efe1f52c-102c-443f-91c3-a9c2edc991eb\e4405554-bd6d-4d28-9e75-819feb748b6a\ifc * Database version: 5507 * Database creation date: Tue Jun 04 15:03:34 2024 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Jun 04 15:03:34 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 04 15:03:34 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_BuildingStoreyCommon - Reference: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Level Head - Circle: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head

# IfcDistributionPort (6)
Description: Flow
Name | FlowDirection
3 x Port_1353215 | SOURCE
Port_1353215 | SOURCEANDSINK
2 x Port_1353215 | SINK

# IfcUnitaryEquipment: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Mark_Tanner_CLA 070-090_INT-EN:Type 070, HC_Air Conditioner_Indoor Unit_F_MEPcontent_Mark_Tanner_CLA 070-090_INT-EN:Type 070:1353215
In: Level 0
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 084-087-089, Color RAL 9010
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 570 mm; Drain Diameter: 16 mm; Height: 250 mm; Hydronic Return Diameter: 19 mm; Hydronic Supply Diameter: 19 mm; Remote Air Diameter: 150 mm; Supply/Fresh Air Connection: 60 mm; Use Nominal Diameter: yes; Width: 570 mm
Type - Electrical Engineering - Phase: 1; Voltage: 230 V
Type - Identity Data - Article Description: Water-powered air heater for suspended ceiling installation; Article Type: Type 070; Base Family Version: 24.07; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Water-powered air heater for suspended ceiling installation; EMCS Version: 5.0; ETIM Article Class: EC011580; Family Version: 24.07; GLN: 8719333004471; GTIN: 8720211952975; Manufacturer: Mark; Manufacturer Art. No.: 5997301; Manufacturer URL: https://www.markclimate.com/products/air-heating/water-supplied-air-heating/tanner-cla-cassette-unit/; MEPcontent Class: AIR_CONDITIONER_INDOOR_UNIT; Model: Type 070; OmniClass Number: 23.75.10.24.21.27; OmniClass Title: Unitary Air Conditioning Equipment; Product Line: Mark; Revit Version: 2022; Type Name: Type 070; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Grey: Color RGB 084-087-089; RAL 9010: Color RAL 9010
Type - Mechanical - Loads - Cooling Air Flow Rate Min (m3/h): 250; Cooling Capacity (kW): 1.27; Heating Air Flow Rate Min (m3/h): 250; Heating Capacity (kW): 1.95; Sound pressure level for cooling (dB(A)): 48; Sound pressure level for heating (dB(A)): 48; Unit Weight (Kg): 18
Type - Other - Category: Mechanical Equipment; Chamfer Length: 55 mm; Clip Outer Height: 520 mm; Family Name: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Mark_Tanner_CLA 070-090_INT-EN; Flange Turnover: 25 mm; Hydronic Return Inner Diameter: 21 mm; Hydronic Return Outer Diameter: 26.9 mm; Hydronic Supply Inner Diameter: 21 mm; Hydronic Supply Outer Diameter: 26.9 mm; Offset1: 1000 mm; Outer Width: 620 mm; Power Supply Diameter: 20 mm; Rod Diameter: 5 mm; Thickness: 10 mm; Total Depth: 280 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Mark
Pset_EnvironmentalImpactIndicators - Reference: Type 070; sets with these values: 2
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 1.95969 m2; Offset from Ceiling: 0 mm; Volume: 0.0913754 m3
Electrical - Loads - Power: 0 W
Identity Data - Mark: 1
Mechanical - System Classification: Power,Supply Air,Other Air,Sanitary,Hydronic Supply,Hydronic Return
Mechanical - Flow - Drain Fixture Units: 0; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Remote Air Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Other - Back Clearance: 0 mm; Bottom Clearance: 280 mm; Bracket Length: 40 mm; Ceiling Offset: 1000 mm; Clip Outer Width: 520 mm; Family: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Mark_Tanner_CLA 070-090_INT-EN: Type 070; Family and Type: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Mark_Tanner_CLA 070-090_INT-EN: Type 070; Front Clearance: 0 mm; Left Clearance: 0 mm; Outer Depth: 620 mm; Right Clearance: 0 mm; Top Clearance: 150 mm; Type: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Mark_Tanner_CLA 070-090_INT-EN: Type 070; Type Id: HC_Air Conditioner_Indoor Unit_F_MEPcontent_Mark_Tanner_CLA 070-090_INT-EN: Type 070
Phasing - Phase Created: New Construction
Visibility - Service Space: no
